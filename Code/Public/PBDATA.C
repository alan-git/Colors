/* *******************************************************************************************
// Author:		biu~
// Last Date:	2018/03/23
// 公共调用函数，头文件中对公共引用数据进行声明；
/* ******************************************************************************************* */

#include "PBDATA.H"

#ifdef USE_SEG
        //*** WARNING L16: UNCALLED SEGMENT, IGNORED FOR OVERLAY PROCESS
        //    SEGMENT: ?CO?PBDATA，在Code区定义了数组，但没有被调用；
const u8 code W_Scan[8] = {0x80,0x40,0x20,0x10,0x08,0x04,0x02,0x01};              
    //const u8 code W_Scan[8] = {0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80};		
const u8 code Seg_7[11] = {0xC0,0xF9,0xA4,0xB0,0x99,0x92,0x82,0xF8,0x80,0x90,0xFF};
#endif

/* *******************************************************************************************
// 延时1US，一般用于驱动中改变引脚电平状态后微量延时；
/* ******************************************************************************************* */
void Delay1US()     //@24.000MHz
{
    unsigned char i;

    _nop_();
    _nop_();
    i = 3;
    while (--i);
}

/* *******************************************************************************************
// US级延时
/* ******************************************************************************************* */
//void DelayUS(u16 x)
//{ 
//    u8 y;
//    while (x--)
//        for (y=0; y<PARAMETER_US; y++); 
//}

/* *******************************************************************************************
// MS级CPU延时
///* ******************************************************************************************* */
void DelayMS(u16 x)
{
    u16 y;
    while (x--)
        for (y=0; y<PARAMETER_MS; y++); 
}

/* *******************************************************************************************
// 系统状态提示灯闪烁
/* ******************************************************************************************* */
//void TestCode()
//{
//#ifdef DeveloperMode
//    SysLED_On();
//    DelayMS(500);
//    SysLED_Off();
//#endif
//	_nop_();
//}

/* *******************************************************************************************
// 系统状态提示灯闪烁
/* ******************************************************************************************* */
void SysLED_Flash(u16 time, u8 times)
{
    u8 i;
    for (i=0; i<times; i++)
    {
        SysLED_On();
        DelayMS(time);
        SysLED_Off();
        DelayMS(time);
    }
}
