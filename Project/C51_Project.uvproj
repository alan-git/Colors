# Keil uVision project C51_Project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: C51-Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Code\DeveloperCode\inc;..\Code\DirverCode\inc;..\Code\Public\inc
  group Public
    ../Code/Public/inc/: INCLUDES.H
    ../Code/Public/: MAIN.C PBDATA.C TIME_BASE.C
  group DirverCode
    ../Code/DirverCode/: Colors.C
  group DeveloperCode
    ../Code/DeveloperCode/: Unknown_Category.C SysSelf-test_And_SysInit.C
